Commit message: updated dynamics

File: mrsgym/models/plane.urdf (robot description, URDF)
Before this commit: robot cube.urdf, 1 links, 0 joints
Links:
- link planeLink: geometry collision box size=30 30 1; visual box size=30 30 1
